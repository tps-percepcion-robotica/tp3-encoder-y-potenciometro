## firmware/esp32_as5600_pote/sdkconfig.defaults
```kconfig
CONFIG_FREERTOS_HZ=1000
CONFIG_ESP_MAIN_TASK_STACK_SIZE=4096
CONFIG_TASK_WDT_TIMEOUT_S=15
```
